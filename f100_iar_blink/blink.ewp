# IAR project blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS\Device\ST\STM32F1xx\Include; CMSIS\Core\Include; User\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/Include/: core_cm1.h
    CMSIS/Device/ST/STM32F1xx/Source/Templates/: startup_stm32f10x_md_vl.s system_stm32f1xx.c
    CMSIS/Device/ST/STM32F1xx/Include/: stm32f100xb.h stm32f1xx.h system_stm32f1xx.h
  group User/inc
    User/inc/: main.h
  group User/src
    User/src/: main.c
